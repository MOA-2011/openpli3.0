SRC_URI="git://git.code.sf.net/p/openpli/enigma2-plugins;protocol=git"
