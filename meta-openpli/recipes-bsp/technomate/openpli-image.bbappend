IMAGE_INSTALL += " \
				  sysfsutils \
				  gmp \
				  tslib \
				  openssl \
				  mtd-utils \
				  kernel-params \
				  python-gdata \
				  busybox-mdev \
				  gst-plugins-ugly \
				  libcrypto-compat \
				  "
