require technomate-dvb-modules-ci.inc
