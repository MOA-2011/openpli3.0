require technomate-dvb-modules.inc

DOWNLOADMACHINE = "${MACHINE}"
RELEASEDIR = ""

SRCDATE = "20131211"
SRC_URI[md5sum] = "fc53d60f2eba6b768e37e5b2b9e55321"
SRC_URI[sha256sum] = "d76a2221f60529febcc7c1ffbe7b78539190ce0e0d2038935a8e95759ff0626f"

