require technomate-dvb-modules.inc

DOWNLOADMACHINE = "${MACHINE}"
RELEASEDIR = ""

SRCDATE = "20131229"
SRC_URI[md5sum] = "d932a20d030dd210b5dbe86fd292aa45"
SRC_URI[sha256sum] = "a7386dd64cba9d5102acfda447e5ddd4039be8d8f14758b4c3f3be807174c4b5"

