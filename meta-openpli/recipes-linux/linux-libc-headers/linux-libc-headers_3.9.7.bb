PRINC = "1"

require linux-libc-headers_3.9.7.inc

SRC_URI[md5sum] = "06e3f307db4ccf7e31775e2903bb973a"
SRC_URI[sha256sum] = "7b221d47e7e5e8cbc6af6e562ab24dcbc5bcde1f55fcf46b280d5bab4d2ba8ad"
