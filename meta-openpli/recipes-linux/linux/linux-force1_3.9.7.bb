SRC_URI += "file://no_check_micom.patch;striplevel=1"

require linux-tmxxoe-3.9.7.inc
