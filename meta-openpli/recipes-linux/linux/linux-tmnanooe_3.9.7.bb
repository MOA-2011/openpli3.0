require linux-tmxxoe-3.9.7.inc

SRC_URI += " \
			file://fix_not_has_nor.patch \
			"
