SRC_URI += "file://boot_mtd.patch;striplevel=1"

require linux-tmxxoe-3.9.7.inc
