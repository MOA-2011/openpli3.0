require conf/license/openpli-gplv2.inc

WIFI_DRIVERS = " \
		firmware-carl9170 \
		\
		firmware-htc7010 \
		firmware-htc9271 \
		\
		firmware-rt2870 \
		kernel-module-rt2800usb \
		kernel-module-rt2500usb \
		\
		firmware-rt73 \
		kernel-module-rt73usb \
		\
		firmware-rt3070 \
		rt3070 \
		\
		firmware-rtl8712u \
		kernel-module-r8712u \
		\
		firmware-zd1211 \
		kernel-module-zd1211rw \
		\
		kernel-module-rtl8187 \
		\
		firmware-rtl8192cu \
		kernel-module-rtl8192cu \
		"
